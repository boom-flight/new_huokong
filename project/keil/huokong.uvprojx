# Keil uVision project huokong.uvprojx, settings and files
target huokong (ARM-CLANG)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3")
  output: huokong +hex
  c define: __RTTHREAD__,STM32F103xB,USE_HAL_DRIVER,SOC_STM32F103C8,RT_NAME_MAX=12,RT_CPUS_NR=1,RT_ALIGN_SIZE=8,RT_THREAD_PRIORITY_32,RT_THREAD_PRIORITY_MAX=32,RT_TICK_PER_SECOND=1000,IDLE_THREAD_STACK_SIZE=256,RT_USING_SEMAPHORE,RT_USING_MUTEX,RT_USING_EVENT,RT_USING_SMALL_MEM,RT_USING_SMALL_MEM_AS_HEAP,RT_USING_HEAP,RT_USING_DEVICE,RT_USING_DEVICE_IPC,RT_UNAMED_PIPE_NUMBER=64,RT_USING_CONSOLE,RT_CONSOLEBUF_SIZE=128,RT_CONSOLE_DEVICE_NAME="uart1",RT_VER_NUM=0x50202,RT_BACKTRACE_LEVEL_MAX_NR=32,RT_USING_HW_ATOMIC,RT_USING_CPU_FFS,ARCH_ARM,ARCH_ARM_CORTEX_M,ARCH_ARM_CORTEX_M3,RT_USING_COMPONENTS_INIT,RT_USING_USER_MAIN,RT_MAIN_THREAD_STACK_SIZE=512,RT_MAIN_THREAD_PRIORITY=10,RT_USING_SERIAL,RT_USING_SERIAL_V1,RT_SERIAL_RB_BUFSZ=64,RT_USING_MESSAGEQUEUE,RT_USING_PIN,PKG_USING_CMSIS_CORE,PKG_USING_CMSIS_CORE_LATEST_VERSION,PKG_USING_STM32F1_HAL_DRIVER,PKG_USING_STM32F1_HAL_DRIVER_LATEST_VERSION,PKG_USING_STM32F1_CMSIS_DRIVER,PKG_USING_STM32F1_CMSIS_DRIVER_LATEST_VERSION,SOC_FAMILY_STM32,SOC_SERIES_STM32F1,BSP_USING_GPIO,BSP_USING_UART,BSP_STM32_UART_V1_TX_TIMEOUT=2000,BSP_USING_UART1,BSP_GPIO_EXTI15_10_EXTERNAL
  c misc: --target=arm-arm-none-eabi -mcpu=cortex-m3 -mthumb --std=c11 -Oz -g
  c include: ..\..;..\..\src;..\..\src\kernel;..\..\src\modules;..\..\src\platform;..\..\vendor\rt-thread\include;..\..\vendor\rt-thread\components\drivers\include;..\..\src\platform\board\stm32f103c8;..\..\src\platform\board\stm32f103c8\CubeMX_Config\Inc;..\..\vendor\cmsis-core\Include;..\..\vendor\stm32f1-cmsis\Include;..\..\vendor\stm32f1-hal\Inc;..\..\src\modules\devices;..\..\src\modules\protocols;..\..\src\debug;..\..\vendor\rt-thread\components\libc\compilers\common\include;..\..\vendor\rt-thread\components\libc\compilers\newlib;..\..\vendor\rt-thread-stm32-drivers;..\..\vendor\rt-thread-stm32-drivers\drivers
  scatter file: stm32f103c8.sct
  link misc: --map --list ..\..\build\keil\stm32f103c8\Debug\Listings\huokong.map
  group application
    ../../src/app/: main.c
  group board
    ../../src/platform/board/stm32f103c8/: board.c
    ../../src/platform/board/stm32f103c8/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
  group kernel
    ../../src/kernel/imu/: imu_policy.c imu_service.c
    ../../src/kernel/logging/: imu_log_event.c imu_log_service.c
    ../../src/kernel/telemetry/: telemetry_policy.c telemetry_service.c
  group modules
    ../../src/modules/attitude/: imu_calibration.c mahony.c
    ../../src/modules/devices/bmi088/: bmi088.c
    ../../src/modules/protocols/imu_telemetry/: imu_telemetry.c
    ../../src/modules/timing/: timestamp_extender.c
    ../../src/modules/transport/: dma_tx_state.c
  group platform
    ../../src/platform/devices/: bmi088_stm32.c
    ../../src/platform/time/: monotonic_clock_stm32.c
    ../../src/platform/transport/: telemetry_uart_stm32.c foxglove_debug_uart_stm32.c
  group debug
    ../../src/debug/: foxglove_debug.c foxglove_debug_console.c foxglove_debug_frame.c
  group rt-thread
    ../../vendor/rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../vendor/rt-thread/src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
    ../../vendor/rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../vendor/rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
    ../../vendor/rt-thread/components/drivers/core/: device.c
    ../../vendor/rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../vendor/rt-thread/components/drivers/pin/: dev_pin.c
    ../../vendor/rt-thread/components/drivers/serial/: dev_serial.c
    ../../vendor/rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../vendor/rt-thread/components/libc/compilers/newlib/: syscalls.c
  group cmsis
    ../../vendor/stm32f1-cmsis/Source/Templates/arm/: startup_stm32f103xb.s
    ../../vendor/stm32f1-cmsis/Source/Templates/: system_stm32f1xx.c
  group hal
    ../../vendor/stm32f1-hal/Src/: stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group drivers
    ../../vendor/rt-thread-stm32-drivers/: drv_common.c
    ../../vendor/rt-thread-stm32-drivers/drivers/: drv_gpio.c drv_usart.c
